# Repository saloni-jain-code/pcb-pendant

File README.md:

# PCB Pendant
Creative Embedded Systems

## Overview

This project is a custom heart-shaped printed circuit board (PCB) that uses a 555 timer chip mode to blink a red LED. The board was designed in KiCad, converted to CNC-compatible SVG files, and milled on a CNC machine.

This repository contains the design files and manufacturing exports necessary to reproduce the PCB (assuming access to required hardware and tools).

## Repository Structure
- `/kicad` contains the original schematic and PCB layout files.
- `/manufacturing` contains SVG files used for CNC milling:
  - Isolation traces
  - Drill holes
  - Board outline

## Materials and Components
- Single-sided copper board for PCB
- CR2032 3V coin battery
- CR2032 battery holder
- 555 timer chip
- Red LED (5mm)
- Resistor R1: 4.7k ohms
- Resistor R2: 68k ohms
- Resistor R3: 470 ohms
- Capacitor C1: 10 nF
- Capacitor C2: 4.7 uF

## CNC Milling Instructions

The provided SVG files are ready for milling in Easel.  
Files included:
- `simple_front.svg` (isolation traces)
- `simple_drill.svg` (drill holes)
- `simple_outline.svg` (heart board outline)
### 1. Easel Setup
Set material dimensions:
- **Material Type:** PCB
- **Width:** 152 mm
- **Length:** 106 mm
- **Thickness:** 1.6 mm
Secure the copper board to the machine bed.
## Step 1: Mill Isolation Traces
1. Select bit:
   - **V Bit – Custom 30° PCB**
   - Change to this bit in the CNC machine too
2. Import:
   - `simple_front.svg`
3. In **Cut Settings**:
   - Depth: **0.08 mm**
   - If traces are not fully isolated, increase to **0.13 mm**
4. Positioning:
   - Move the design outside of the clamp/red zone
   - Place it toward the **bottom right** of the material
5. Import `simple_outline.svg`
   - Align it with your PCB
   - Record the X and Y position values
   - Delete the heart outline before carving
6. Click **Carve**
## Step 2: Drill Holes
1. Import:
   - `simple_drill.svg`
2. Manually align drill holes to match the milled traces.
3. Delete the isolation trace geometry (only drill holes should remain).
4. Change bit to:
   - **End Mills → Upcut 1/32 in Fishtail Spiral (0.8 mm)**
5. Right-click drill geometry → **Convert to Drill Holes**
6. Cut settings:
   - Depth: **1.6 mm**
   - **Add Depth: +0.2 mm**
7. Click **Carve**
## Step 3: Cut Board Outline
1. Remove drill hole geometry.
2. Import:
   - `simple_outline.svg`
3. Set X and Y positions using the values recorded earlier.
4. Change bit to:
   - **1/8 in Double Flute Straight End Mill**
5. Set:
   - Tabs: **2 tabs**
   - Tab length: **2 mm**
6. Click **Carve**
After carving, carefully remove the board and cut tabs manually if needed.

## Soldering
Using the diagram below or the kicad files, solder the hardware components listed above accordingly.
Note:
- Ensure correct orientation of 555 timer chip (circle should be in top left and indicates ground)
- Ensure correct orientation of LED (shorter end corresponds to ground)

## KiCad design kicad/555timerCES.kicad_pcb

Board: 2 copper layers, 85.2 x 83.9 mm, 8 parts (0 on the bottom side), 7 nets.

Parts:
BT2: BAT-HLD-003-SMT; BAT_BAT-HLD-003-SMT
C1: C; C_Disc_D6.0mm_W4.4mm_P5.00mm
C2: 10n; C_Disc_D6.0mm_W4.4mm_P5.00mm
D1: LED; LED_D1.8mm_W3.3mm_H2.4mm
R1, R2, R3: R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U1: TLC555xP; DIP-8_W7.62mm

Connections:
+3V0: BT2.P1, BT2.P2, R1.1, U1.4 (R), U1.8 (VCC)
GND: BT2.N, C1.1, C2.2, D1.1 (K), U1.1 (GND)
unnamed: D1.2 (A), R3.1
unnamed: C2.1, U1.5 (CV)
unnamed: R1.2, R2.1, U1.7 (DIS)
unnamed: R3.2, U1.3 (Q)
unnamed: C1.2, R2.2, U1.2 (TR), U1.6 (THR)

## Commit log

2026-02-12 Update README for heart-shaped 555 timer PCB project
    Updated project title and provided detailed overview, repository structure, hardware requirements, materials, and reproduction instructions for the heart-shaped 555 timer PCB project.
2026-02-12 Add pcb pendant gif
2026-02-12 Add pcb pendant gif to readme
    Updated project description for clarity and fixed formatting issues.
2026-02-12 added svg files for milling
2026-02-12 added kicad schematic and pcb layout
2026-02-12 Rename project to 'PCB Pendant' and revise intro
    Updated project title and removed specific details.
2026-02-12 Add CNC Milling Instructions to README
    Added detailed CNC milling instructions including setup, milling isolation traces, drilling holes, and cutting board outline steps.
2026-02-12 Delete hardware requirements from README
    Removed hardware requirements section from README.
2026-02-12 Fix Soldering section header and add orientation notes
    Updated the Soldering section header and added notes on component orientation.
